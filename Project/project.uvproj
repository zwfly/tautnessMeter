# Keil uVision project project.uvproj, settings and files
target meter (MCS-51)
  device: N76E616 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0xFF) CLOCK(16000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_110592
  c include: ..\Common\inc;..\App\inc;..\Bsp\inc;..\Startup;..\Bsp
  asm include: ..\Common\inc
  group App
    ../App/src/: main.c app_key.c app_work.c app_repeat_exe.c app_charge.c app_battery.c
    ../App/inc/: app.h
  group Bsp
    ../Bsp/: bsp.c
    ../Bsp/src/: bsp_beep.c bsp_key.c bsp_bright.c bsp_bt.c bsp_display.c bsp_hall.c bsp_uart.c bsp_timer0.c bsp_timer1.c bsp_adc.c
  group Common
    ../Common/src/: Common.c Delay.c Display.c Version.c
  group Startup
    ../Startup/: STARTUP.A51
  group Doc
    ../Doc/: readme.txt
